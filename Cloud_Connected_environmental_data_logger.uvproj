# Keil uVision project Cloud_Connected_environmental_data_logger.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Cloud_Connected_environmental_data_logger
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s uart0.c esp01.c adc.c i2c_eeprom.c interrupt.c delay.c i2c.c main.c lcd.c mq2.c keypad.c keypaddefines.c
